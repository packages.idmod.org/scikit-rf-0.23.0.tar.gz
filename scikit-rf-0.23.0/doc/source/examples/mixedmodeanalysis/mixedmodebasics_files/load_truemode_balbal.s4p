!Agilent Technologies,N5225A,MY51451011,A.09.90.21
!Agilent N5225A: A.09.90.21
!Date: Tuesday, July 07, 2020 17:08:48
!Correction: Sdd11(Full 4 Port(1,2,3,4))
!Sdc11(Full 4 Port(1,2,3,4))
!Sdd12(Full 4 Port(1,2,3,4))
!Sdc12(Full 4 Port(1,2,3,4))
!Scd11(Full 4 Port(1,2,3,4))
!Scc11(Full 4 Port(1,2,3,4))
!Scd12(Full 4 Port(1,2,3,4))
!Scc12(Full 4 Port(1,2,3,4))
!Sdd21(Full 4 Port(1,2,3,4))
!Sdc21(Full 4 Port(1,2,3,4))
!Sdd22(Full 4 Port(1,2,3,4))
!Sdc22(Full 4 Port(1,2,3,4))
!Scd21(Full 4 Port(1,2,3,4))
!Scc21(Full 4 Port(1,2,3,4))
!Scd22(Full 4 Port(1,2,3,4))
!Scc22(Full 4 Port(1,2,3,4))
!Balanced Topology: BBAL
!S4P File: Measurements: <Sdd11,Sdc11,Sdd12,Sdc12>,
!<Scd11,Scc11,Scd12,Scc12>,
!<Sdd21,Sdc21,Sdd22,Sdc22>,
!<Scd21,Scc21,Scd22,Scc22>:
# Hz S  RI  R 50
! Worked out from all points (4-port):
!   2001 points, 1 GHz to 11 GHz, reference 50 ohm
!   strongest paths, dB at 1 GHz, 3.5 GHz, 6 GHz, 8.5 GHz, 11 GHz:
!     S43: -53.2, -42.6, -37.4, -34.5, -31.9
!     S42: -68.1, -59.8, -56.5, -53.2, -54.5
!     S31: -73.2, -63.1, -57.6, -54.5, -52.1
!     S32: -86.1, -70.0, -63.7, -60.6, -57.2
!     S21: -64.1, -64.8, -64.1, -57.7, -78.8
!     S41: -107.8, -83.2, -82.0, -81.4, -70.1
!   lowest |S11| = -46.6 dB at 1 GHz (marker M1), VSWR 1.01, Z = 49.9 - j0.456 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
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! magnitudes (dB):
! f  S11  S43  S42  S31  S32  S21  S41
! 1 GHz  -46.6  -53.2  -68.1  -73.2  -86.1  -64.1  -107.8
! 7.61 GHz  -29.6  -35.6  -53.5  -55.5  -60.6  -64.0  -77.5
! 8.325 GHz  -28.7  -34.7  -53.6  -54.7  -60.5  -58.2  -84.0
! 9.205 GHz  -27.8  -33.6  -53.7  -54.1  -59.9  -62.3  -75.6
! 9.755 GHz  -27.3  -33.0  -54.5  -53.5  -58.5  -56.2  -77.4
! 10.46 GHz  -26.5  -32.4  -54.3  -53.1  -57.2  -56.6  -71.8
! 11 GHz  -26.1  -31.9  -54.5  -52.1  -57.2  -78.8  -70.1
