!  4-Port S-parameters saved by WinCal
! VAR MeasName=S-Parameters (CALIBRATED_DATA) read from VNA (N5225A)
! VAR MeasDate=7/7/2020 2:51:53 PM
! VAR NAME=load_se
! VAR FILENAME=load_se.S4P
! VAR DATE=7/7/2020 2:51:53 PM
! VAR PHYS_PORTS=1,2,3,4
# Hz S RI R 50
! Worked out from all points (4-port):
!   2001 points, 1 GHz to 11 GHz, reference 50 ohm
!   strongest paths, dB at 1 GHz, 3.5 GHz, 6 GHz, 8.5 GHz, 11 GHz:
!     S31: -44.2, -33.9, -29.2, -26.2, -23.7
!     S42: -49.9, -39.1, -34.5, -31.5, -29.3
!     S21: -69.8, -60.1, -54.9, -52.4, -51.2
!     S43: -70.9, -64.0, -60.6, -56.5, -56.8
!     S32: -76.1, -68.2, -65.3, -63.8, -65.9
!     S41: -80.2, -82.8, -67.7, -67.9, -58.0
!   lowest |S11| = -56.5 dB at 1.13 GHz (marker M1), VSWR 1.00, Z = 49.9 + j0.132 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
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! magnitudes (dB):
! f  S11  S31  S42  S21  S43  S32  S41
! 1 GHz  -55.5  -44.2  -49.9  -69.8  -70.9  -76.1  -80.2
! 1.13 GHz  -56.5  -43.4  -48.5  -67.9  -73.1  -80.0  -80.2
! 3.665 GHz  -46.2  -33.5  -38.7  -59.1  -63.7  -70.0  -72.1
! 4.33 GHz  -44.7  -32.1  -37.3  -57.9  -61.8  -70.2  -72.8
! 6.195 GHz  -41.7  -28.9  -34.2  -55.3  -58.2  -67.4  -68.5
! 7.345 GHz  -40.2  -27.5  -32.8  -52.4  -56.4  -64.8  -79.2
! 11 GHz  -36.9  -23.7  -29.3  -51.2  -56.8  -65.9  -58.0
