! 2/19/2018 12:56:37 PM
! E:\STEPPED_EXPERIMENT_2018-02-19\P2-MSL_OPEN_50.S1P
! CHANNEL.1
! TR.MEASUREMENT
! CORRECTED.DATA
# GHZ S RI R 50.0
! FREQ.GHZ  S22RE  S22IM
!; PortSelection: Port_2
! Worked out from all points (one-port):
!   10000 points, 1 MHz to 10 GHz, reference 50 ohm
!   lowest |S11| = -11.9 dB at 6.523 GHz (marker M1), VSWR 1.68, Z = 31.6 + j9.82 ohm
!   |S11| at or under -10 dB: 6.421 GHz to 6.585 GHz (164.1 MHz wide, 2.52 % of centre)
!   the Smith chart shows 5.408 GHz to 7.484 GHz only
!   S11 on the Smith chart (normalised r, x): 5.408 GHz: 0.22, +1.05; 5.722 GHz: 4.34, -0.84; 6.215 GHz: 0.49, -0.29; 6.747 GHz: 0.30, +0.60; 7.077 GHz: 2.12, +3.37; 7.484 GHz: 0.47, -1.58
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! magnitudes (dB):
! f  S11
! 1 MHz  0.0
! 1.251 GHz  -0.3
! 2.501 GHz  -0.7
! 3.751 GHz  -1.2
! 5.001 GHz  -1.6
! 5.408 GHz  -1.8
! 5.587 GHz  -2.6
! 5.722 GHz  -3.9
! 6 GHz  -8.1
! 6.126 GHz  -8.5
! 6.215 GHz  -8.1
! 6.251 GHz  -8.1
! 6.359 GHz  -8.6
! 6.474 GHz  -10.8
! 6.523 GHz  -11.9
! 6.56 GHz  -11.2
! 6.658 GHz  -7.0
! 6.747 GHz  -3.9
! 6.866 GHz  -2.6
! 7.077 GHz  -2.2
! 7.484 GHz  -2.2
! 7.501 GHz  -2.3
! 7.849 GHz  -2.6
! 8.389 GHz  -3.4
! 8.751 GHz  -2.9
! 9.104 GHz  -2.2
! 9.39 GHz  -2.3
! 10 GHz  -4.9
