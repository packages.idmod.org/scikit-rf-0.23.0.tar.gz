!Created with skrf (http://scikit-rf.org).
# Hz S RI R 50.0
!freq ReS11 ImS11 ReS21 ImS21 ReS12 ImS12 ReS22 ImS22
! Worked out from all points (through path):
!   4400 points, 1 MHz to 4.4 GHz, reference 50 ohm
!   highest |S21| = 1.15 dB at 505 MHz (marker M1); lowest = -4.5 dB at 3.213 GHz (marker M2)
!   lowest |S11| = -59.7 dB at 2.313 GHz (marker M3), VSWR 1.00, Z = 49.9 + j0.0398 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
!   S12 and S22 are empty: the file has one direction only
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! magnitudes (dB):
! f  S11  S21
! 1 MHz  -39.0  -0.4
! 505 MHz  -23.7  1.1
! 735 MHz  -25.0  0.9
! 1.468 GHz  -17.7  0.2
! 1.548 GHz  -32.6  0.3
! 1.641 GHz  -18.1  0.3
! 1.703 GHz  -51.3  0.2
! 1.771 GHz  -18.3  -0.1
! 1.848 GHz  -42.1  -0.4
! 1.921 GHz  -17.2  -0.8
! 2.007 GHz  -47.4  -1.1
! 2.201 GHz  -20.5  -2.0
! 2.313 GHz  -59.7  -2.3
! 2.385 GHz  -19.3  -2.9
! 2.46 GHz  -46.5  -3.0
! 2.535 GHz  -19.3  -3.5
! 2.612 GHz  -40.2  -3.5
! 2.687 GHz  -19.6  -3.6
! 2.934 GHz  -29.9  -4.0
! 3.213 GHz  -30.3  -4.5
! 3.667 GHz  -35.8  -3.2
! 4.4 GHz  -16.3  -1.7
