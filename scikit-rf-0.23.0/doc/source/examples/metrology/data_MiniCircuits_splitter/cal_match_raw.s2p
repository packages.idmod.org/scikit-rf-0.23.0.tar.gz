!Created with skrf (http://scikit-rf.org).
# Hz S RI R 50.0
!freq ReS11 ImS11 ReS21 ImS21 ReS12 ImS12 ReS22 ImS22
! Worked out from all points (weakly coupled two-port):
!   4400 points, 1 MHz to 4.4 GHz, reference 50 ohm
!   highest |S21| = -43.49 dB at 4.08 GHz (marker M1); lowest = -131.9 dB at 1.895 GHz (marker M2)
!   lowest |S11| = -32.4 dB at 444 MHz (marker M3), VSWR 1.05, Z = 52.4 + j0.134 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
!   S12 and S22 are empty: the file has one direction only
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! magnitudes (dB):
! f  S11  S21
! 1 MHz  -25.8  -87.8
! 166 MHz  -31.4  -91.6
! 322 MHz  -25.1  -93.5
! 444 MHz  -32.4  -114.6
! 581 MHz  -23.0  -90.4
! 735 MHz  -27.6  -85.6
! 883 MHz  -21.4  -87.0
! 1.303 GHz  -26.4  -92.8
! 1.468 GHz  -19.4  -94.2
! 1.895 GHz  -25.5  -131.9
! 2.201 GHz  -26.5  -85.7
! 2.934 GHz  -23.2  -74.6
! 3.031 GHz  -29.6  -76.1
! 3.121 GHz  -23.8  -79.8
! 3.334 GHz  -30.0  -70.5
! 3.51 GHz  -23.0  -59.9
! 3.667 GHz  -28.5  -62.8
! 3.871 GHz  -25.7  -47.5
! 3.945 GHz  -29.2  -49.2
! 4.08 GHz  -20.2  -43.5
! 4.16 GHz  -19.8  -48.3
! 4.4 GHz  -16.7  -61.4
