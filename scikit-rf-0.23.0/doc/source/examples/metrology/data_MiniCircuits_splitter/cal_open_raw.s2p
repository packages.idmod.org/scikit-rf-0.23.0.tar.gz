!Created with skrf (http://scikit-rf.org).
# Hz S RI R 50.0
!freq ReS11 ImS11 ReS21 ImS21 ReS12 ImS12 ReS22 ImS22
! Worked out from all points (weakly coupled two-port):
!   4400 points, 1 MHz to 4.4 GHz, reference 50 ohm
!   highest |S21| = -44.63 dB at 4.08 GHz (marker M1); lowest = -128.5 dB at 505 MHz (marker M2)
!   lowest |S11| = -5.9 dB at 4.032 GHz (marker M3), VSWR 3.06, Z = 18.5 - j16.9 ohm
!   |S11| at or under -10 dB: nowhere
!   S12 and S22 are empty: the file has one direction only
!   the Smith chart shows 3.814 GHz to 4.251 GHz only
!   S11 on the Smith chart (normalised r, x): 3.814 GHz: 0.28, +0.51; 3.898 GHz: 2.21, +3.02; 3.983 GHz: 0.60, -1.03; 4.083 GHz: 0.28, +0.17; 4.167 GHz: 0.46, +1.62; 4.251 GHz: 1.87, -2.21
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! magnitudes (dB):
! f  S11  S21
! 1 MHz  0.0  -85.5
! 505 MHz  -0.5  -128.5
! 735 MHz  -1.1  -98.9
! 1.468 GHz  -1.3  -88.0
! 2.201 GHz  -1.9  -79.3
! 2.629 GHz  -4.0  -82.3
! 2.784 GHz  -4.3  -92.8
! 2.934 GHz  -3.8  -75.1
! 3.12 GHz  -5.4  -85.2
! 3.38 GHz  -4.5  -72.2
! 3.497 GHz  -4.4  -60.7
! 3.667 GHz  -4.3  -63.0
! 3.705 GHz  -5.3  -66.2
! 3.814 GHz  -3.9  -50.0
! 3.898 GHz  -2.6  -48.3
! 3.983 GHz  -4.7  -49.4
! 4.032 GHz  -5.9  -46.1
! 4.08 GHz  -5.0  -44.6
! 4.083 GHz  -4.8  -51.9
! 4.167 GHz  -2.1  -48.5
! 4.251 GHz  -3.7  -54.5
! 4.4 GHz  -3.2  -64.3
