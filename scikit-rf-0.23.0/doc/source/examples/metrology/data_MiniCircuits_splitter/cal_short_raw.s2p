!Created with skrf (http://scikit-rf.org).
# Hz S RI R 50.0
!freq ReS11 ImS11 ReS21 ImS21 ReS12 ImS12 ReS22 ImS22
! Worked out from all points (weakly coupled two-port):
!   4400 points, 1 MHz to 4.4 GHz, reference 50 ohm
!   highest |S21| = -42.53 dB at 4.08 GHz (marker M1); lowest = -125.9 dB at 888 MHz (marker M2)
!   lowest |S11| = -5.5 dB at 4.179 GHz (marker M3), VSWR 3.27, Z = 20 - j26 ohm
!   |S11| at or under -10 dB: nowhere
!   S12 and S22 are empty: the file has one direction only
!   the Smith chart shows 3.973 GHz to 4.38 GHz only
!   S11 on the Smith chart (normalised r, x): 3.973 GHz: 0.24, +0.50; 4.048 GHz: 1.12, +2.79; 4.132 GHz: 0.77, -1.37; 4.23 GHz: 0.25, +0.03; 4.305 GHz: 0.21, +1.14; 4.38 GHz: 7.58, -0.31
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! magnitudes (dB):
! f  S11  S21
! 1 MHz  -3.3  -99.1
! 735 MHz  -0.8  -93.0
! 888 MHz  -1.6  -125.9
! 1.468 GHz  -1.6  -91.8
! 2.201 GHz  -3.0  -79.3
! 2.842 GHz  -2.4  -79.6
! 2.934 GHz  -3.9  -74.0
! 3.119 GHz  -2.7  -75.4
! 3.374 GHz  -3.8  -69.8
! 3.509 GHz  -3.5  -60.9
! 3.667 GHz  -3.9  -61.4
! 3.704 GHz  -2.9  -63.6
! 3.846 GHz  -4.4  -46.8
! 3.973 GHz  -3.4  -51.3
! 4.048 GHz  -2.0  -54.1
! 4.08 GHz  -2.5  -42.5
! 4.132 GHz  -4.2  -48.5
! 4.179 GHz  -5.5  -49.2
! 4.23 GHz  -4.5  -55.7
! 4.305 GHz  -1.6  -59.0
! 4.38 GHz  -2.3  -60.2
! 4.4 GHz  -2.8  -60.6
