!Created with skrf (http://scikit-rf.org).
# GHz S RI R 50.0
!freq ReS11 ImS11 ReS21 ImS21 ReS12 ImS12 ReS22 ImS22
! Worked out from all points (through path):
!   647 points, 75 GHz to 110 GHz, reference 50 ohm
!   highest |S21| = 1.26 dB at 96.83 GHz (marker M1); lowest = 0.7 dB at 76.52 GHz (marker M2)
!   lowest |S11| = -41.4 dB at 80.1 GHz (marker M3), VSWR 1.02, Z = 50.8 + j0.357 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
!   |S22| runs from -49.7 to -34.7 dB; largest |S21 - S12| = 0
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 75 GHz  -31.2  0.8  0.8  -35.5
! 76.03 GHz  -38.5  0.9  0.9  -46.1
! 76.52 GHz  -37.4  0.7  0.7  -40.7
! 78.85 GHz  -30.8  0.9  0.9  -38.2
! 80.1 GHz  -41.4  0.9  0.9  -42.1
! 80.85 GHz  -30.6  0.8  0.8  -35.9
! 82.1 GHz  -39.1  1.0  1.0  -38.8
! 83.24 GHz  -29.4  1.0  1.0  -38.4
! 86.7 GHz  -34.1  0.8  0.8  -39.5
! 89.09 GHz  -30.8  1.1  1.1  -36.0
! 90.12 GHz  -33.7  0.8  0.8  -49.7
! 91.31 GHz  -32.0  1.0  1.0  -38.7
! 92.5 GHz  -33.1  0.8  0.8  -39.6
! 93.31 GHz  -32.6  1.0  1.0  -37.8
! 94.61 GHz  -32.1  0.9  0.9  -46.2
! 96.83 GHz  -34.1  1.3  1.3  -37.2
! 98.35 GHz  -32.0  0.8  0.8  -42.5
! 102.3 GHz  -38.3  0.9  0.9  -38.6
! 104.2 GHz  -30.3  0.8  0.8  -38.6
! 105.8 GHz  -35.9  0.9  0.9  -45.4
! 107.6 GHz  -31.4  0.9  0.9  -36.0
! 110 GHz  -35.0  0.9  0.9  -39.1
