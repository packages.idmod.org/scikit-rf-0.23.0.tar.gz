!Created with skrf (http://scikit-rf.org).
# GHz S RI R 50.0
!freq ReS11 ImS11 ReS21 ImS21 ReS12 ImS12 ReS22 ImS22
! Worked out from all points (one-way two-port):
!   647 points, 75 GHz to 110 GHz, reference 50 ohm
!   highest |S21| = -50.53 dB at 77.39 GHz (marker M1); lowest = -130.0 dB at 85.3 GHz (marker M2)
!   lowest |S11| = 1.2 dB at 81.02 GHz (marker M3)
!   |S11| at or under -10 dB: nowhere
!   |S22| runs from -3.5 to -1.4 dB; largest |S21 - S12| = 0.0044
!   the Smith chart shows 80.53 GHz to 81.56 GHz only
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 75 GHz  1.6  -61.1  -64.7  -2.9
! 77.39 GHz  2.0  -50.5  -64.8  -2.6
! 79.23 GHz  1.6  -57.4  -85.6  -2.4
! 80.85 GHz  1.6  -58.2  -59.3  -2.7
! 81.02 GHz  1.2  -61.5  -54.0  -2.9
! 85.3 GHz  1.5  -130.0  -59.7  -2.7
! 86.7 GHz  1.7  -66.1  -63.6  -2.6
! 91.8 GHz  1.7  -57.9  -66.5  -2.7
! 92.5 GHz  1.5  -67.5  -75.6  -2.8
! 95.1 GHz  2.2  -54.7  -62.0  -2.7
! 95.59 GHz  2.3  -77.3  -57.9  -2.2
! 96.08 GHz  2.1  -60.4  -64.4  -2.3
! 96.45 GHz  1.9  -61.6  -66.3  -2.6
! 98.35 GHz  1.6  -64.6  -61.1  -2.8
! 99.33 GHz  1.5  -77.3  -63.9  -3.1
! 100.8 GHz  1.8  -61.5  -57.5  -2.2
! 103 GHz  1.9  -66.1  -55.0  -2.4
! 103.7 GHz  1.5  -56.5  -68.4  -2.2
! 104.2 GHz  1.5  -64.4  -59.9  -2.2
! 107.5 GHz  1.8  -62.9  -67.8  -2.0
! 107.8 GHz  1.8  -55.8  -55.8  -2.4
! 110 GHz  1.9  -60.1  -60.9  -2.1
