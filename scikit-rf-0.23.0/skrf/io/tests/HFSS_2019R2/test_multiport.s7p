! Touchstone file from project test_multiport
! Exported from HFSS 2019.2.0
!Data is not renormalized
# GHZ S MA
! Modal data exported
! Port[1] = 1:1
! Port[2] = 2:1
! Port[3] = 3:1
! Port[4] = 4:1
! Port[5] = 5:1
! Port[6] = 6:1
! Port[7] = 7:1
! Worked out from all points (7-port):
!   5 points, 900 MHz to 1.1 GHz, reference per port
!   strongest paths, dB at 900 MHz, 950 MHz, 1 GHz, 1.05 GHz, 1.1 GHz:
!     S21: -110.3, -110.0, -109.6, -109.2, -108.8
!     S64: -112.1, -111.6, -111.1, -110.6, -110.0
!     S61: -113.9, -113.2, -112.5, -111.7, -110.8
!     S41: -123.1, -122.2, -121.2, -120.2, -119.1
!     S62: -124.9, -124.2, -123.5, -122.7, -121.8
!     S54: -131.4, -130.9, -130.3, -129.7, -129.0
!   lowest |S11| = -63.8 dB at 1.1 GHz (marker M1), VSWR 1.00
!   |S11| at or under -10 dB: start of sweep to end of sweep
