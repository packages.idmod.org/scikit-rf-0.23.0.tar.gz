! Touchstone file from project test_multiport
! Exported from HFSS 2019.2.0
!Data is not renormalized
# GHZ S MA
! Modal data exported
! Port[1] = 1:1
! Port[2] = 2:1
! Port[3] = 3:1
! Port[4] = 4:1
! Port[5] = 5:1
! Port[6] = 6:1
! Port[7] = 7:1
! Port[8] = 8:1
! Port[9] = 9:1
! Worked out from all points (9-port):
!   5 points, 900 MHz to 1.1 GHz, reference per port
!   strongest paths, dB at 900 MHz, 950 MHz, 1 GHz, 1.05 GHz, 1.1 GHz:
!     S21: -109.9, -109.5, -109.1, -108.7, -108.3
!     S64: -112.0, -111.5, -111.0, -110.4, -109.8
!     S61: -113.8, -113.1, -112.4, -111.6, -110.8
!     S41: -123.0, -122.1, -121.1, -120.1, -119.0
!     S62: -124.8, -124.1, -123.4, -122.6, -121.7
!     S91: -129.2, -129.4, -129.6, -130.0, -130.6
!   lowest |S11| = -64.0 dB at 1.1 GHz (marker M1), VSWR 1.00
!   |S11| at or under -10 dB: start of sweep to end of sweep
