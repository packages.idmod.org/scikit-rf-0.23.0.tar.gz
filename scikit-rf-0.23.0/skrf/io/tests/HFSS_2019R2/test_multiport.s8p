! Touchstone file from project test_multiport
! Exported from HFSS 2019.2.0
!Data is not renormalized
# GHZ S MA
! Modal data exported
! Port[1] = 1:1
! Port[2] = 2:1
! Port[3] = 3:1
! Port[4] = 4:1
! Port[5] = 5:1
! Port[6] = 6:1
! Port[7] = 7:1
! Port[8] = 8:1
! Worked out from all points (8-port):
!   5 points, 900 MHz to 1.1 GHz, reference per port
!   strongest paths, dB at 900 MHz, 950 MHz, 1 GHz, 1.05 GHz, 1.1 GHz:
!     S21: -110.4, -110.0, -109.7, -109.3, -108.9
!     S64: -112.3, -111.9, -111.3, -110.8, -110.2
!     S61: -113.9, -113.2, -112.5, -111.7, -110.9
!     S41: -123.4, -122.5, -121.5, -120.5, -119.4
!     S62: -125.1, -124.4, -123.6, -122.8, -121.9
!     S54: -130.7, -130.2, -129.6, -129.0, -128.4
!   lowest |S11| = -65.6 dB at 1.1 GHz (marker M1), VSWR 1.00
!   |S11| at or under -10 dB: start of sweep to end of sweep
